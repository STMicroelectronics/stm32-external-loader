# IAR project MT25QL512A_STM32469I-EVAL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: STM32F469xx
  ICCARM.CCIncludePath2: ..\..\Drivers\BSP\Components\n25q512a; ..\..\Drivers\BSP\Components\s25fl512s; ..\..\Drivers\BSP\STM32469I_EVAL; ..\..\Drivers\CMSIS\Core\Include; ..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\Flash_loader\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MT25QL512A_STM32469I-EVAL.srec
  ILINK.IlinkOutputFile: MT25QL512A_STM32469I-EVAL.stldr
  ILINK.IlinkIcfFile: Target.icf
  ILINK.IlinkProgramEntryLabel: Init
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Drivers/BSP/STM32469-EVAL
    ../../Drivers/BSP/STM32469I_EVAL/: stm32469i_eval_qspi.c
  group Drivers/CMSIS/Device/STM32F4xx/Source/Template
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver/Src
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c
  group Flash_loader/Src
    ../../Flash_loader/Src/: Dev_Inf.c Loader_Src.c
