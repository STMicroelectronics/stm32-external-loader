<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\MX25LM51245G_STM32L4P5G-DK.ewp</path>
    </project>
    <batchBuild />
</workspace>
