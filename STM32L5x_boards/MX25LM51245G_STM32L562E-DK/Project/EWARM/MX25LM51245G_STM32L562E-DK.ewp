# IAR project MX25LM51245G_STM32L562E-DK.ewp, settings and files
configuration MX25LM51245G_STM32L562E-DK (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: STM32L562xx
  ICCARM.CCIncludePath2: ..\..\Includes\Library; ..\..\Includes\Loader; ..\..\Includes\CMSIS
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MX25LM51245G_STM32L562E-DK.hex
  ILINK.IlinkOutputFile: MX25LM51245G_STM32L562E-DK.stldr
  ILINK.IlinkIcfFile: Target.icf
  ILINK.IlinkProgramEntryLabel: Init
  group Doc
    ../../: readme.txt
  group Library
    ../../Sources/Library/: mx25lm51245g.c stm32l562e_discovery_ospi.c stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_dma.c stm32l5xx_hal_gpio.c stm32l5xx_hal_ospi.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c system_stm32l5xx.c
  group Loader
    ../../Sources/Loader/: Dev_Inf.c Loader_Src.c
