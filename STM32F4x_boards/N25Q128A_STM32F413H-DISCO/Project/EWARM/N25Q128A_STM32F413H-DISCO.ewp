# IAR project N25Q128A_STM32F413H-DISCO.ewp, settings and files
configuration N25Q128A_STM32F413H-DISCO (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: STM32F413xx
  ICCARM.CCIncludePath2: ..\..\Includes\Library; ..\..\Includes\Loader; ..\..\Includes\CMSIS
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: N25Q128A_STM32F413H-DISCO.hex
  ILINK.IlinkOutputFile: N25Q128A_STM32F413H-DISCO.stldr
  ILINK.IlinkIcfFile: Target.icf
  ILINK.IlinkProgramEntryLabel: Init
  group Doc
    ../../: readme.txt
  group Library
    ../../Sources/Library/: stm32f413h_discovery_qspi.c stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c system_stm32f4xx.c
  group Loader
    ../../Sources/Loader/: Dev_Inf.c Loader_Src.c
