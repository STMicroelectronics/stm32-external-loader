# IAR project M29W128GL_STM32H743I-EVAL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743I-EVAL ST STM32H743I-EVAL
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCIncludePath2: ..\..\Includes\CMSIS; ..\..\Includes\Library; ..\..\Includes\Loader
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: M29W128GL_STM32H743I-EVAL.srec
  ILINK.IlinkOutputFile: M29W128GL_STM32H743I-EVAL.stldr
  ILINK.IlinkIcfFile: Target.icf
  ILINK.IlinkProgramEntryLabel: Init
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Docs
    ../../: readme.txt ReleaseNotes.txt
  group Library
    ../../Sources/Library/: STM32H7FMC.c stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_msp.c stm32h7xx_hal_nor.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_it.c stm32h7xx_ll_fmc.c stm32h7xxfmc.c system_stm32h7xx.c
  group Source
    ../../Sources/Loader/: Dev_Inf.c Loader_Src.c
