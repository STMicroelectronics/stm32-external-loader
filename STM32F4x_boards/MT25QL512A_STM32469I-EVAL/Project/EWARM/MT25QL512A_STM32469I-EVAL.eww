<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\MT25QL512A_STM32469I-EVAL.ewp</path>
    </project>
    <batchBuild />
</workspace>
