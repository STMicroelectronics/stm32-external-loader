# IAR project MX25LM51245G_STM32U575I-EVAL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32U575I-EV ST STM32U575I-EV
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCIncludePath2: ..\..\Includes\CMSIS; ..\..\Includes\Library; ..\..\Includes\Loader
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MX25LM51245G_STM32U575I-EVAL.srec
  ILINK.IlinkOutputFile: MX25LM51245G_STM32U575I-EVAL.stldr
  ILINK.IlinkIcfFile: Target.icf
  ILINK.IlinkProgramEntryLabel: Init
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Docs
    ../../: readme.txt ReleaseNotes.txt
  group Library
    ../../Sources/Library/: mx25lm51245g.c stm32u575i_eval_ospi.c stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_ospi.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c system_stm32u5xx.c
  group Loader
    ../../Sources/Loader/: Dev_Inf.c Loader_Src.c
