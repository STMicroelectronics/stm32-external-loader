<?xml version='1.0' encoding='UTF-8'?>
<workspace>
 <project>
  <path>$WS_DIR$\MT25QL512ABB_STM32G474E-EVAL.ewp</path>
 </project>
 <batchBuild/>
</workspace>
