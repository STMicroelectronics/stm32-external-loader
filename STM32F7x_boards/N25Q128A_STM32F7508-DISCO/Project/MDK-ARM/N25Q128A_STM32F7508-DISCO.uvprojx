# Keil uVision project N25Q128A_STM32F7508-DISCO.uvprojx, settings and files
target N25Q128A_STM32F7508-DISCO (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: N25Q128A_STM32F7508-DISCO
  AfterMake: cmd.exe /C copy "!L" ".\@L.stldr"
  c flags: Optim=1 oTime=1 v6Lang=1 v6LangP=1
  c define: FLASH_MEM STM32F750XX
  c include: ..\..\Includes\CMSIS;..\..\Includes\Library;..\..\Includes\Loader
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Library
    ../../Sources/Library/: Flash_QSPI_Micron.c stm32f7xx_gpio.c stm32f7xx_quadspi.c stm32f7xx_rcc.c system_stm32f7xx.c
  group Loader
    ../../Sources/Loader/: Dev_Inf.c Loader_Src.c
  group Doc
    ../../: readme.txt
