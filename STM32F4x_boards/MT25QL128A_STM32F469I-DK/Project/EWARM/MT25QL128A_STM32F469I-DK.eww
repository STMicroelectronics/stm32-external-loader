<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\MT25QL128A_STM32F469I-DK.ewp</path>
    </project>
    <batchBuild />
</workspace>
