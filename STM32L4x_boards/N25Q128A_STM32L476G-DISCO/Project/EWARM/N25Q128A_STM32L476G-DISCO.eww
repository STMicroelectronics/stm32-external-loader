<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\N25Q128A_STM32L476G-DISCO.ewp</path>
    </project>
    <batchBuild />
</workspace>
