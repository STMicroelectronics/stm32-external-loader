<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\M29W128GL_STM32H743I-EVAL.ewp</path>
    </project>
    <batchBuild />
</workspace>
