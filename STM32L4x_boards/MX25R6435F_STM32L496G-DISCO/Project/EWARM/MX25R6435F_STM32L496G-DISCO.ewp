# IAR project MX25R6435F_STM32L496G-DISCO.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: STM32L496xx
  ICCARM.CCIncludePath2: ..\..\Drivers\BSP\Components\mx25r6435f; ..\..\Drivers\BSP\STM32L496G-Discovery; ..\..\Drivers\CMSIS\Core; ..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\Flash_loader\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MX25R6435F_STM32L496G-DISCO.srec
  ILINK.IlinkOutputFile: MX25R6435F_STM32L496G-DISCO.stldr
  ILINK.IlinkIcfFile: Target.icf
  ILINK.IlinkProgramEntryLabel: Init
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Drivers/BSP/STM32L496G-Discovery
    ../../Drivers/BSP/STM32L496G-Discovery/: stm32l496g_discovery_qspi.c
  group Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates
    ../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver/Src
    ../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c
  group Flash_loader/Src
    ../../Flash_loader/Src/: Dev_Inf.c Loader_Src.c
