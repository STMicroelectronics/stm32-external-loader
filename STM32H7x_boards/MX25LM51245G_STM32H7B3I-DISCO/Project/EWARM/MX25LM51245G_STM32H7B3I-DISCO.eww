<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\MX25LM51245G_STM32H7B3I-DISCO.ewp</path>
    </project>
    <batchBuild />
</workspace>
