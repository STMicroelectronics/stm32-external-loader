<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\MT25TL01G_STM32H747I-EVAL.ewp</path>
    </project>
    <batchBuild />
</workspace>
