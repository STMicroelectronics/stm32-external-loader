# IAR project MX25LM51245G_STM32U585I-IOT02A.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: B-U585I-IOT02A ST B-U585I-IOT02A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\Includes\CMSIS; ..\..\Includes\Library; ..\..\Includes\Loader
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: MX25LM51245G_STM32U585I-IOT02A.stldr
  ILINK.IlinkIcfFile: Target.icf
  ILINK.IlinkProgramEntryLabel: Init
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Docs
    ../../: readme.txt ReleaseNotes.txt
  group Library
    ../../Sources/Library/: b_u585i_iot02_ospi.c mx25lm51245g.c stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_ospi.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c system_stm32u5xx.c
  group Loader
    ../../Sources/Loader/: Dev_Inf.c Loader_Src.c
