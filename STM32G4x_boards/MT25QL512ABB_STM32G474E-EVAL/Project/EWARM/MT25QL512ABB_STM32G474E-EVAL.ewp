# IAR project MT25QL512ABB_STM32G474E-EVAL.ewp, settings and files
configuration MT25QL512ABB_STM32G474E-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: STM32G474xx
  ICCARM.CCIncludePath2: ..\..\Includes\Library; ..\..\Includes\Loader; ..\..\Includes\CMSIS
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MT25QL512ABB_STM32G474E-EVAL.hex
  ILINK.IlinkOutputFile: MT25QL512ABB_STM32G474E-EVAL.stldr
  ILINK.IlinkIcfFile: Target.icf
  ILINK.IlinkProgramEntryLabel: Init
  group Doc
    ../../: readme.txt ReleaseNotes.txt
  group Library
    ../../Sources/Library/: mt25ql512abb.c stm32g474e_eval_qspi.c stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_gpio.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_qspi.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c system_stm32g4xx.c
  group Loader
    ../../Sources/Loader/: Dev_Inf.c Loader_Src.c
