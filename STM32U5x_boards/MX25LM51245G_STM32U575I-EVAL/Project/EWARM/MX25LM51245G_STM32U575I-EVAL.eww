<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\MX25LM51245G_STM32U575I-EVAL.ewp</path>
    </project>
    <batchBuild />
</workspace>
