<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\MX25R6435F_STM32L496G-DISCO.ewp</path>
    </project>
    <batchBuild />
</workspace>
