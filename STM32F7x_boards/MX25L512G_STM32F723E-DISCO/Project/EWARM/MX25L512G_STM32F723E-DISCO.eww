<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\MX25L512G_STM32F723E-DISCO.ewp</path>
    </project>
    <batchBuild />
</workspace>
