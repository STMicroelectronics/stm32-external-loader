# IAR project MX25LM51245G_STM32H7B3I-EVAL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7B3I-EVAL ST STM32H7B3I-EVAL
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32H7B3xxQ
  ICCARM.CCIncludePath2: ..\..\Drivers\BSP\Components\mx25lm51245g; ..\..\Drivers\BSP\STM32H7B3I-EVAL; ..\..\Drivers\CMSIS\Core; ..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\Flash_loader\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MX25LM51245G_STM32H7B3I-EVAL.srec
  ILINK.IlinkOutputFile: MX25LM51245G_STM32H7B3I-EVAL.stldr
  ILINK.IlinkIcfFile: \Target.icf
  ILINK.IlinkProgramEntryLabel: Init
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Documentation
    ../../Documentation/: Readme.md ReleaseNote.md
  group Drivers/BSP/Components/mx25lm51245g
    ../../Drivers/BSP/Components/mx25lm51245g/: mx25lm51245g.c
  group Drivers/BSP/STM32H7B3I-EVAL
    ../../Drivers/BSP/STM32H7B3I-EVAL/: stm32h7b3i_eval_ospi.c
  group Drivers/CMSIS/Device/STM32H7xx/Source/Template
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver/Src
    ../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_flash.c stm32h7xx_hal_gpio.c stm32h7xx_hal_mdma.c stm32h7xx_hal_nor.c stm32h7xx_hal_ospi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c
  group Flash_loader/Src
    ../../Flash_loader/Src/: Dev_Inf.c Loader_Src.c
