# IAR project MX25LM51245G_STM32H7B3I-DISCO.ewp, settings and files
configuration MX25LM51245G_STM32H7B3I-DISCO (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H7A3xxQ; USE_STM32H7B3I_EVA; CORE_CM7
  ICCARM.CCIncludePath2: ..\..\Includes\CMSIS; ..\..\Includes\Library; ..\..\Includes\Loader
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MX25LM51245G_STM32H7B3I-DISCO.bin
  ILINK.IlinkOutputFile: MX25LM51245G_STM32H7B3I-DISCO.stldr
  ILINK.IlinkIcfFile: Target.icf
  ILINK.IlinkProgramEntryLabel: Init
  group Doc
    ../../: readme.txt
  group Driver
    ../../Sources/Library/: mx25lm51245g.c stm32h7b3i_discovery_ospi.c stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_mdma.c stm32h7xx_hal_ospi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rng_ex.c system_stm32h7xx.c
  group FlashLoader
    ../../Sources/Loader/: Dev_Inf.c Loader_Src.c
