# IAR project MX25LM51245G_STM32H573I-DK.ewp, settings and files
configuration MX25LM51245G_STM32H573I-DK (ARM, debug)
  General.OGChipSelectEditMenu: STM32H573I-DK ST STM32H573I-DK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 0
  ICCARM.CCDefines: STM32H573xx
  ICCARM.CCIncludePath2: ..\..\Drivers\BSP\Components\mx25lm51245g; ..\..\Drivers\BSP\STM32H573I-DK; ..\..\Drivers\CMSIS\Include; ..\..\Drivers\CMSIS\Device\ST\STM32H5xx\Include; ..\..\Drivers\STM32H5xx_HAL_Driver\Inc; ..\..\Flash_loader\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MX25LM51245G_STM32H573I-DK.hex
  ILINK.IlinkOutputFile: MX25LM51245G_STM32H573I-DK.stldr
  ILINK.IlinkIcfFile: Target.icf
  ILINK.IlinkProgramEntryLabel: Init
  group Doc
    ../../: Readme.md
  group Drivers/BSP/Components/mx25lm51245g
    ../../Drivers/BSP/Components/mx25lm51245g/: mx25lm51245g.c
  group Drivers/BSP/STM32H573I-DK
    ../../Drivers/BSP/STM32H573I-DK/: stm32h573i_discovery_ospi.c
  group Drivers/CMSIS/Device/ST/STM32H5xx/Source/Templates
    ../../Drivers/CMSIS/Device/ST/STM32H5xx/Source/Templates/: system_stm32h5xx.c
  group Drivers/STM32H5xx_HAL_Driver/Src
    ../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_xspi.c stm32h5xx_ll_dlyb.c
  group Flash_loader/Src
    ../../Flash_loader/Src/: Dev_Inf.c Loader_Src.c
