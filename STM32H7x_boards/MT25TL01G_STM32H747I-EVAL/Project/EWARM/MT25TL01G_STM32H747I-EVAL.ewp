# IAR project MT25TL01G_STM32H747I-EVAL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32H747I-EVAL_M7 ST STM32H747I-EVAL_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCIncludePath2: ..\..\Includes\CMSIS; ..\..\Includes\Library; ..\..\Includes\Loader
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: MT25TL01G_STM32H747I-EVAL.stldr
  ILINK.IlinkIcfFile: C:\Users\fedi bouzazi\Desktop\3-15\Git\Project\EWARM\Target.icf
  ILINK.IlinkProgramEntryLabel: Init
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Doc
    ../../: readme.txt ReleaseNotes.txt
  group Library
    ../../Sources/Library/: mt25tl01g.c stm32h747i_eval_qspi.c stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c system_stm32h7xx.c
  group Loader
    ../../Sources/Loader/: Dev_Inf.c Loader_Src.c
